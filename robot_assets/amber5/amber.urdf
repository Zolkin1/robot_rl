Commit message: barely working amber added

File: robot_assets/amber5/amber.urdf (robot description, URDF)
Before this commit: robot amber3_PF, 11 links, 10 joints
Links:
- link left_toe: mass 0.0 -> 0.3
- link right_toe: mass 0.0 -> 0.3
